Commit message: 太久沒推送，推送一下，之後會按照日誌推送

File: catkin_ws/src/minibot_description/urdf/minibot_gazebo.urdf (robot description, URDF)
Before this commit: robot minibot, 2 links, 1 joints
Joints:
- joint base_to_laser: origin xyz=0.0675 0.0 0.15 rpy=0 0 0 -> xyz=-0.0675 0.0 0.15 rpy=0 0 0
