Commit message: demo結束推送

File: catkin_ws/src/minibot_description/urdf/minibot.urdf (robot description, URDF)
Before this commit: robot minibot, 2 links, 1 joints
Joints:
- joint base_to_laser: origin xyz=0.0675 0.0 0.15 rpy=0 0 0 -> xyz=0.08 0.0 0.15 rpy=0 0 0
